# Keil uVision project CV8F5025_XN297L.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8052AH Intel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(12000000)
  output: CV8F5025_XN297L +hex
  AfterMake: obj/HEX80CONVERT_V1.03.exe  /W:8 /D:26624/S:CV8F5025_XN297L.hex
  c flags: Optimize=8 SizeSpeed=1
  c define: __KEIL_C51__
  c include: .\code\app\inc;.\code\driver\inc;.\code\system\inc;.\code\usb
  group app
    ./code/app/src/: main.c uart2usb.c usb_app.c rf.c interrupt.c ascii2hid.c STARTUP.A51
    ./code/: XN297L.LIB
  group usb
    ./code/: USB.LIB
    ./code/usb/: usb_descript.c
  group driver
    ./code/driver/src/: drv_clock.c drv_gpio.c drv_timer.c drv_uart.c drv_serial.c drv_flash.c drv_watchdog.c drv_spi_simulate.c
  group system
    ./code/system/src/: delay.c initial.c checkout.c it_config.c
